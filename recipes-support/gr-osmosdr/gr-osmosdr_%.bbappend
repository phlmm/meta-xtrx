FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
PACKAGECONFIG ?= ""
EXTRA_OECMAKE ?= ""
DEPENDS += "libxtrx"

