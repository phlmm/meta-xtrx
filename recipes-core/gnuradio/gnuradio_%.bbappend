PACKAGECONFIG = "zeromq logging"
DEPENDS += "soapysdr libiio libxtrx"
